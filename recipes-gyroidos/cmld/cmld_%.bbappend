DEPENDS += "efivar"
RDEPENDS:cmld += "efivar"
