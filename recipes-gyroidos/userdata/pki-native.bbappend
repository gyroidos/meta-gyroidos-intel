export LD_LIBRARY_PATH = "${STAGING_LIBDIR}"
DEPENDS += " sbsigntool-native efitools-native"
