inherit gyroidoskeytool

DECRIPTION = "KeyTool image"

DEPENDS= "efitools-native"

IMAGE_LINUGUAS = " "

LICENSE = "GPL-2.0-only"

IMAGE_FEATURES = ""

export IMAGE_BASENAME = "gyroidos-keytool"
IMAGE_FSTYPES = "gyroidoskeytool"
inherit image

IMAGE_ROOTFS_SIZE = "4096"
