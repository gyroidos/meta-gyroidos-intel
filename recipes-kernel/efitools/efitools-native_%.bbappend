SRC_URI += "file://0001-lib-console-compatibly-fix-to-upstream-change-of-gnu.patch"
